# Keil uVision project UART0_terminal.uvproj, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: UART0_terminal
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=5
  c define: rvmdk PART_TM4C123GH6PM
  c include: C:\ti\TivaWare_C_Series-2.2.0.295
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: startup_rvmdk.S UART_sample.c
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
